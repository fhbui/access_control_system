# Keil uVision project access_control_system.uvprojx, settings and files
target access_control_system (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: access_control_system +hex
  AfterMake: J:\software\Keil_v5_32\ARM\ARMCC\bin\fromelf.exe --bin --output .\access_control_system\access_control_system.bin .\access_control_system\*.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Code/BSP;../Code/UI;../Code;../Middlewares/Third_Party/LVGL/LVGL_SRC;../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl;../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src;../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/examples/porting;../Middlewares/Third_Party/LVGL/APPS/demos;../Middlewares/Third_Party/LVGL/APPS/demos/widgets/assets;../Code/APP/UI;../Code/APP;../Code/Components;../Code/Services
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Code/APP/UI
    ../Code/APP/UI/: ui_main.c ui_main.h ui_router.c ui_router.h ui_service.c ui_service.h ui_styles.c ui_styles.h ui_widgets.c ui_widgets.h
    ../Code/APP/UI/ui_page/: page_card.c page_finger.c page_main.c page_password.c
  group Code/APP
    ../Code/APP/: app_interface.h app_main.c app_main.h
  group Code/Service
    ../Code/Services/: svr_card.c svr_card.h svr_doorlock.c svr_doorlock.h svr_fingerprint.c svr_fingerprint.h svr_ota.c svr_ota.h
  group Code/Component
    ../Code/Components/: ft6336.c ft6336.h ili9341.c ili9341.h rc522.c rc522.h w25qxx.c w25qxx.h as608.c as608.h aes128.c aes128.h hmac.c hmac.h sha256.c sha256.h ota_protocol.c ota_protocol.h
  group Code/BSP
    ../Code/BSP/: bsp_flash.c bsp_flash.h bsp_i2c.c bsp_i2c.h bsp_spi.c bsp_spi.h bsp_uart.c bsp_uart.h bsp_dwt.c bsp_dwt.h
  group Code
    ../Code/: log.c log.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL/conf
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/: lv_conf.h lvgl.h
  group Middlewares/LVGL/example/porting
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group Middlewares/LVGL/src/core
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/LVGL/src/draw
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group Middlewares/LVGL/src/extra
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/extra/: lv_extra.c
  group Middlewares/LVGL/src/font
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/LVGL/src/hal
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/LVGL/src/misc
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/LVGL/src/widgets
    ../Middlewares/Third_Party/LVGL/LVGL_SRC/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/LVGL/demo
    ../Middlewares/Third_Party/LVGL/APPS/demos/widgets/: lv_demo_widgets.c
    ../Middlewares/Third_Party/LVGL/APPS/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
software components: CMSIS:CORE 4.3.0
